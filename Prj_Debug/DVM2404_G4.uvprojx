# Keil uVision project DVM2404_G4.uvprojx, settings and files
target DVM2404_G4 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32G473RCTx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.5.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: DVM2404_G4 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32G473xx
  c include: ../Core/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../Drivers/CMSIS/Include;../Inc;../canopen;..\User;..\Lib
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/MDK-ARM
    ./: startup_stm32g473xx.s
    ./: startup_stm32g431xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32g4xx_it.c stm32g4xx_hal_msp.c
    ../User/: Device.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g4xx.c
  group Plc
    ../Plc/: iCAN_Master.c iCAN_slave.c iCANLogic.c iCANPlc.c iTimer.c Message.c PARA.c PLCLogic.c Queue.c Temprature.c Packet.c uartSTM32F4.c canSTM32G4.c HourCount.c
    ../User/: PLC.c
  group Kernel
    ../User/: CommonRam.c MC_MotorControl_Layer.c
    ../Kernel/: AutoTune.c FDB.c Current.c
  group User
    ../User/: CanOpen_QexpandAgvV04.c USER_NBRY.c USER_ZHONGLI.c CanOpen_HangChaApp.c USER_LINDE_STEER.c CanOpen_Linde.c
  group canopen
    ../CANopen/: mco.c mcohw_LPC2.c user_QExpand.c
  group Lib
    ../Lib/: IQmathLib.lib IQmathLib.h
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_adc.c stm32g4xx_hal_adc_ex.c stm32g4xx_ll_adc.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_fdcan.c stm32g4xx_hal_spi.c stm32g4xx_hal_spi_ex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c stm32g4xx_hal_usart.c stm32g4xx_hal_usart_ex.c stm32g4xx_hal_iwdg.c
  group Readme
    ../: readme.txt
software components: CMSIS:CORE 5.5.0
